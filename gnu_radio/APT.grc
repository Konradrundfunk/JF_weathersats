options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: if_samp_rate
  id: variable
  parameters:
    value: '9600.0'
  states: {}
- name: if_samp_rate_2
  id: variable
  parameters:
    value: '11025'
  states: {}
- name: if_samp_rate_3
  id: variable
  parameters:
    value: '6225'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '37500.0'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '700'
    audio_stop: '1400'
    chan_rate: samp_rate
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-2400'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-2400'
    offset: '0'
    phase: '0'
    samp_rate: if_samp_rate_2
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '9600'
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {state: disabled}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/konrad/Downloads/APT-testfiles/090729 1428 noaa-18 8bitresample.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/konrad/Downloads/APT-testfiles/090729 1428 noaa-18 11025samples.wav
    repeat: 'False'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1400'
    decim: '1'
    gain: '1'
    samp_rate: if_samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {state: bypassed}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1400'
    decim: '1'
    gain: '1'
    samp_rate: if_samp_rate_3
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {state: bypassed}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"resample old"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '37000'
    fc: '0'
    fftsize: '1024'
    name: '"after multiply"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"entry"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: if_samp_rate_2
    fc: '0'
    fftsize: '1024'
    name: '"bevore multiply"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"resample new"'
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    axislabels: 'False'
    color1: '2'
    grid: 'True'
    mult: '[1]'
    ncols: '4800'
    nrows: '1000'
    samp_rate: if_samp_rate
    type: float
    update_time: '0.001'
    zmax: '0.1'
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    axislabels: 'False'
    color1: '2'
    grid: 'True'
    ncols: '4800'
    nrows: '1000'
    samp_rate: if_samp_rate
    type: float
    update_time: '0.001'
    zmax: '100'
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_1
  id: qtgui_time_raster_sink_x
  parameters:
    axislabels: 'False'
    color1: '2'
    grid: 'True'
    mult: '[1]'
    ncols: '3112'
    nrows: '740'
    samp_rate: if_samp_rate_3
    type: float
    update_time: '0.001'
    zmax: '0.1'
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '32'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '147'
    interp: '83'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_am_demod_cf_0, '0', audio_sink_0, '0']
- [analog_am_demod_cf_0, '0', qtgui_time_raster_sink_x_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_mag_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_raster_sink_x_0_1, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_multiply_xx_0, '0', analog_am_demod_cf_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_wavfile_source_0, '0', audio_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_0, '0', audio_sink_1_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_float_to_complex_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0_1, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0_1, '0', qtgui_freq_sink_x_0_1, '0']

metadata:
  file_format: 1
