options:
  parameters:
    generate_options: qt_gui
    id: apt_gnuradio_demod
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: input_sample_rate
  id: variable
  parameters:
    value: '176400'
  states: {}
- name: output_sample_rate
  id: variable
  parameters:
    value: '8820'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/konrad/Downloads/APT-testfiles/176400_noaa.wav
    repeat: 'False'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2400'
    gain: '1'
    interp: '1'
    samp_rate: input_sample_rate
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '1'
    ncols: '4410'
    nrows: '300'
    samp_rate: output_sample_rate
    type: float
    zmax: '0.3'
    zmin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    type: fff
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_wavfile_source_0_0_0, '0', low_pass_filter_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', hilbert_fc_0, '0']

metadata:
  file_format: 1
